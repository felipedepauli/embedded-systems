# Keil uVision project blinky.uvprojx, settings and files
target blinky (6180000::V6.18::ARMCLANG)
  device: TM4C129ENCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  AfterMake: fromelf --bin --output .\rvmdk\blinky.bin .\rvmdk\blinky.axf
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_TM4C129ENCPDT TARGET_IS_TM4C129_RA1
  c misc: --c99
  c include: ..\..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: blinky.sct
  link misc: --entry Reset_Handler
  group Source
    ./: blinky.c startup_rvmdk.S
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
